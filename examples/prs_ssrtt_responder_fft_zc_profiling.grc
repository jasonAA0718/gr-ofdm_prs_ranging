options:
  parameters:
    comment: SS-RTT responder with FFT-ZC detector and per-stage profiling.
    description: OFDM PRS SS-RTT responder FFT-ZC detector profiling
    generate_options: no_gui
    id: prs_ssrtt_responder_fft_zc_profiling
    output_language: python
    title: PRS SS-RTT Responder FFT-ZC Profiling
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1060e6
  states: {}
- name: premble_length
  id: variable
  parameters:
    value: '256'
  states: {}
- name: premble_rep
  id: variable
  parameters:
    value: '4'
  states: {}
- name: reply_delay_samples
  id: variable
  parameters:
    value: int(0.05*samp_rate)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(30e6)
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '67'
  states: {}
- name: zc_length
  id: variable
  parameters:
    value: '419'
  states: {}
- name: prs_acquisition_logger_0
  id: ofdm_prs_ranging_prs_acquisition_logger
  parameters:
    append: '1'
    comment: Logs every detected POLL before responder filtering
    node: '"responder"'
    path: '"CSV/FFT_profiling/responder_fft_zc_acquisition_v4.csv"'
  states: {}
- name: prs_channel_estimator_0
  id: ofdm_prs_ranging_prs_channel_estimator
  parameters:
    active_bins: '512'
    enable_profiling: 'True'
    fft_len: '512'
    mc_ds_gold_code_id: '2'
    prs_symbols: '127'
    samp_rate: samp_rate
    seed: '13990001'
  states: {}
- name: prs_csv_logger_0
  id: ofdm_prs_ranging_prs_csv_logger
  parameters:
    append: '1'
    comment: Records POLL PRS CFO and phase-slope measurements
    enable_profiling: 'True'
    path: '"CSV/FFT_profiling/responder_fft_zc_measurements.csv"'
  states: {}
- name: prs_fft_receiver_0
  id: ofdm_prs_ranging_prs_fft_receiver
  parameters:
    active_bins: '512'
    cp_len: '64'
    enable_profiling: 'True'
    fft_len: '512'
    prs_symbols: '127'
    samp_rate: samp_rate
  states: {}
- name: prs_frame_detector_0_0_0
  id: ofdm_prs_ranging_prs_fft_zc_frame_detector
  parameters:
    active_bins: '512'
    cfo_compensation: 'True'
    channel_id: '0'
    coarse_sync_len: zc_length
    coarse_zc_root: '25'
    comment: Connect UHD Source here
    correlation_fft_len: '8192'
    cp_len: '64'
    enable_profiling: '0'
    fft_len: '512'
    min_frame_gap: '10000'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '127'
    reply_delay_s: '0.08'
    samp_rate: samp_rate
    tail_guard_len: '1000'
    threshold: '0.35'
    time_gating: 'False'
    window_after_s: '0.0012'
    window_before_s: '0.0002'
    zc_search_after: 8192-512
    zc_search_before: '512'
    zc_threshold: '0.5'
    zero_guard_len: '1000'
  states: {}
- name: prs_phase_slope_estimator_0
  id: ofdm_prs_ranging_prs_phase_slope_estimator
  parameters:
    active_bins: '512'
    enable_profiling: 'True'
    fft_len: '512'
    max_residual_rms: '1.0'
    samp_rate: samp_rate
  states: {}
- name: prs_source
  id: ofdm_prs_ranging_prs_timed_burst_source
  parameters:
    active_bins: '512'
    attach_tx_time: 'True'
    burst_period: '0.2'
    coarse_sync_len: zc_length
    coarse_zc_root: '29'
    cp_len: '64'
    fft_len: '512'
    mc_ds_gold_code_id: '2'
    pings_per_trigger: '1'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '127'
    samp_rate: samp_rate
    seed: '13990001'
    tail_guard_len: '1000'
    tx_amp: '0.7'
    tx_lead_time: '0.6'
    zero_guard_len: '1000'
  states: {}
- name: prs_ssrtt_responder_0
  id: ofdm_prs_ranging_prs_ssrtt_responder
  parameters:
    enable_profiling: 'True'
    reply_delay_samples: reply_delay_samples
    samp_rate: samp_rate
  states: {}
- name: prs_timing_collector_0
  id: ofdm_prs_ranging_prs_timing_collector
  parameters:
    comment: Buffered per-stage timing output; files are finalized when the flowgraph stops
    raw_csv_path: '"CSV/FFT_profiling/responder_fft_zc_timing_raw.csv"'
    role: '"responder"'
    summary_csv_path: '"CSV/FFT_profiling/responder_fft_zc_timing_summary.csv"'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0563"'
    gain0: tx_gain
    minoutbuf: |
      1048576
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0563"'
    dev_args: '"recv_buff_size=20000000,num_recv_frames=700"'
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: trigger_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tx_time_out
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: 'Frame_Detector_time '
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: FFT_Receiver_time
  states: {}
- name: virtual_sink_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Channel_time
  states: {}
- name: virtual_sink_1_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Phase_Slope_time
  states: {}
- name: virtual_sink_1_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RTT_Solver_time
  states: {}
- name: virtual_sink_1_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: CSV_time
  states: {}
- name: virtual_sink_1_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Channel_est
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: trigger_out
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: 'Frame_Detector_time '
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: FFT_Receiver_time
  states: {}
- name: virtual_source_1_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: Channel_time
  states: {}
- name: virtual_source_1_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: Phase_Slope_time
  states: {}
- name: virtual_source_1_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: RTT_Solver_time
  states: {}
- name: virtual_source_1_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: CSV_time
  states: {}
- name: virtual_source_1_0_0_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Channel_est
  states: {}

connections:
- [prs_channel_estimator_0, channel_out, virtual_sink_1_0_0_0_0_1, '0']
- [prs_channel_estimator_0, event_out, prs_acquisition_logger_0, frame_in]
- [prs_channel_estimator_0, timing_out, virtual_sink_1_0_0_0_0, '0']
- [prs_csv_logger_0, timing_out, virtual_sink_1_0_0_0_0_0_0_0, '0']
- [prs_fft_receiver_0, symbols_out, prs_channel_estimator_0, symbols_in]
- [prs_fft_receiver_0, timing_out, virtual_sink_1_0_0_0, '0']
- [prs_frame_detector_0_0_0, event_out, prs_acquisition_logger_0, frame_in]
- [prs_frame_detector_0_0_0, frame_out, prs_fft_receiver_0, frame_in]
- [prs_frame_detector_0_0_0, timing_out, virtual_sink_1_0_0, '0']
- [prs_phase_slope_estimator_0, measurement_out, prs_csv_logger_0, measurement_in]
- [prs_phase_slope_estimator_0, measurement_out, prs_ssrtt_responder_0, measurement_in]
- [prs_phase_slope_estimator_0, timing_out, virtual_sink_1_0_0_0_0_0, '0']
- [prs_source, '0', uhd_usrp_sink_0, '0']
- [prs_source, tx_time_out, virtual_sink_0_0, '0']
- [prs_ssrtt_responder_0, timing_out, virtual_sink_1_0_0_0_0_0_0, '0']
- [prs_ssrtt_responder_0, trigger_out, virtual_sink_0, '0']
- [uhd_usrp_source_0_0, '0', prs_frame_detector_0_0_0, '0']
- [virtual_source_0, '0', prs_source, trigger]
- [virtual_source_1_0_0, '0', prs_timing_collector_0, timing_in]
- [virtual_source_1_0_0_0, '0', prs_timing_collector_0, timing_in]
- [virtual_source_1_0_0_0_1, '0', prs_timing_collector_0, timing_in]
- [virtual_source_1_0_0_0_1_0, '0', prs_timing_collector_0, timing_in]
- [virtual_source_1_0_0_0_1_0_0, '0', prs_timing_collector_0, timing_in]
- [virtual_source_1_0_0_0_1_0_0_0, '0', prs_timing_collector_0, timing_in]
- [virtual_source_1_0_0_0_1_0_0_0_0, '0', prs_frame_detector_0_0_0, prs_cfo_in]
- [virtual_source_1_0_0_0_1_0_0_0_0, '0', prs_phase_slope_estimator_0, channel_in]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
