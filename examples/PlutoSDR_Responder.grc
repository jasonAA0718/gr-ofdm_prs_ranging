options:
  parameters:
    author: cnsl
    description: PlutoSDR untimed PRS responder with bounded raw capture
    generate_options: no_gui
    id: PlutoSDR_Responder
    output_language: python
    title: PlutoSDR PRS Responder
  states: {}

blocks:
- name: capture_samples
  id: variable
  parameters:
    comment: Two seconds; complex float32 is 80 MB/s at 10 MS/s
    value: int(2*samp_rate)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(1060e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: acquisition_log
  id: ofdm_prs_ranging_prs_acquisition_logger
  parameters:
    append: 'True'
    node: '"pluto_responder"'
    path: '"CSV/pluto_responder_acquisition.csv"'
  states: {}
- name: channel_estimator
  id: ofdm_prs_ranging_prs_channel_estimator
  parameters:
    active_bins: '1024'
    fft_len: '1024'
    prs_symbols: '16'
    samp_rate: samp_rate
    seed: '13990001'
  states: {}
- name: detector
  id: ofdm_prs_ranging_prs_frame_detector
  parameters:
    active_bins: '1024'
    channel_id: '25'
    coarse_sync_len: '839'
    coarse_zc_root: '25'
    cp_len: '128'
    fft_len: '1024'
    min_frame_gap: '10000'
    preamble_len: '128'
    preamble_repeats: '16'
    prs_symbols: '16'
    reply_delay_s: '0.05'
    samp_rate: samp_rate
    tail_guard_len: '1000'
    threshold: '0.35'
    time_gating: 'False'
    window_after_s: '0.004'
    window_before_s: '0.0002'
    zc_threshold: '0.35'
    zero_guard_len: '1000'
  states: {}
- name: fft_receiver
  id: ofdm_prs_ranging_prs_fft_receiver
  parameters:
    active_bins: '1024'
    cp_len: '128'
    fft_len: '1024'
    prs_symbols: '16'
    samp_rate: samp_rate
  states: {}
- name: iio_rx
  id: iio_pluto_source
  parameters:
    bandwidth: '10000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.6.10
  states: {}
- name: iio_tx
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '10000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.6.10
  states: {}
- name: measurement_log
  id: ofdm_prs_ranging_prs_csv_logger
  parameters:
    append: 'True'
    path: '"CSV/pluto_responder_phase_slope.csv"'
  states: {}
- name: phase_slope
  id: ofdm_prs_ranging_prs_phase_slope_estimator
  parameters:
    active_bins: '1024'
    fft_len: '1024'
    max_residual_rms: '1.0'
    samp_rate: samp_rate
  states: {}
- name: pluto_tx
  id: ofdm_prs_ranging_pluto_prs_burst_source
  parameters:
    active_bins: '1024'
    coarse_sync_len: '839'
    coarse_zc_root: '29'
    cp_len: '128'
    default_packet_type: '2'
    fft_len: '1024'
    guard_samples: '0'
    preamble_len: '128'
    preamble_repeats: '16'
    prs_symbols: '16'
    samp_rate: samp_rate
    seed: '13990001'
    tail_guard_len: '1000'
    tx_amp: '0.6'
    zero_guard_len: '1000'
  states: {}
- name: response_control
  id: ofdm_prs_ranging_pluto_prs_responder
  parameters:
    guard_samples: '0'
  states: {}
- name: rx_file
  id: blocks_file_sink
  parameters:
    file: '"CSV/pluto_responder_rx.c64"'
    type: complex
  states: {state: disabled}
- name: rx_head
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {state: disabled}
- name: text_ui
  id: ofdm_prs_ranging_prs_text_ui
  parameters:
    refresh_period_s: '0.25'
    response_timeout_s: '1.0'
    role: '"responder"'
    stale_timeout_s: '1.5'
    use_ansi: 'True'
  states: {}
- name: tx_file
  id: blocks_file_sink
  parameters:
    file: '"CSV/pluto_responder_tx.c64"'
    type: complex
  states: {state: disabled}
- name: tx_head
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {state: disabled}

connections:
- [channel_estimator, channel_out, phase_slope, channel_in]
- [detector, event_out, acquisition_log, frame_in]
- [detector, frame_out, fft_receiver, frame_in]
- [detector, frame_out, response_control, frame_in]
- [detector, frame_out, text_ui, frame_in]
- [fft_receiver, symbols_out, channel_estimator, symbols_in]
- [iio_rx, '0', detector, '0']
- [iio_rx, '0', rx_head, '0']
- [phase_slope, measurement_out, measurement_log, measurement_in]
- [phase_slope, measurement_out, text_ui, measurement_in]
- [pluto_tx, '0', iio_tx, '0']
- [pluto_tx, '0', tx_head, '0']
- [pluto_tx, tx_event_out, text_ui, tx_in]
- [response_control, trigger_out, pluto_tx, trigger]
- [rx_head, '0', rx_file, '0']
- [tx_head, '0', tx_file, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
