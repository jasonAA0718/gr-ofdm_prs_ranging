options:
  parameters:
    description: OFDM PRS-like timed TX at 10 MHz and 1399 MHz
    generate_options: qt_gui
    id: prs_tx_10M_1399
    output_language: python
    title: PRS TX 10M 1399
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1399e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: optional TX reference
    file: captures/tx_prs_10M_1399.c64
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: complex
  states: {}
- name: prs_source
  id: ofdm_prs_ranging_prs_timed_burst_source
  parameters:
    active_bins: '600'
    attach_tx_time: 'True'
    burst_period: '0.5'
    coarse_sync_len: '839'
    cp_len: '128'
    fft_len: '1024'
    pings_per_trigger: '10'
    preamble_len: '128'
    preamble_repeats: '16'
    prs_symbols: '16'
    samp_rate: samp_rate
    seed: '13990001'
    tail_guard_len: '1000'
    tx_amp: '0.7'
    tx_lead_time: '1.0'
    zero_guard_len: '1000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: PRS TX
    name: '"PRS TX Spectrum"'
    tr_level: '-60'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: PRS TX
    name: '"PRS TX Time"'
    size: '4096'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
  states: {}
- name: send_prs
  id: variable_qtgui_msg_push_button
  parameters:
    label: Send PRS
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0563"'
    dev_args: '"rcvr_buff_size=10000000,num_recv_frames=700"'
    gain0: tx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0563"'
    dev_args: '"recv_buff_size=20000000,num_recv_frames=700"'
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [prs_source, '0', blocks_multiply_const_vxx_0, '0']
- [send_prs, pressed, prs_source, trigger]
- [uhd_usrp_source_0_0, '0', prs_source, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
