options:
  parameters:
    description: Raw complex64 PRS capture at 10 MHz and 1399 MHz
    generate_options: qt_gui
    id: prs_rx_capture_10M_1399
    output_language: python
    title: PRS RX Capture 10M 1399
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {bus_structure: 'null'}
- name: center_freq
  id: variable
  parameters:
    value: 1399e6
  states: {bus_structure: 'null'}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {bus_structure: 'null'}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: captures/rx_prs_10M_1399.c64
    type: complex
  states: {bus_structure: 'null'}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: PRS RX
    name: '"PRS RX Time"'
    size: '4096'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
  states: {bus_structure: 'null'}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: PRS RX
    name: '"PRS RX Spectrum"'
    tr_level: '-60'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
  states: {bus_structure: 'null'}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    gain0: rx_gain
    gain_type0: normalized
    len_tag_name: '""'
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: none
    type: fc32
  states: {bus_structure: 'null'}

connections:
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
