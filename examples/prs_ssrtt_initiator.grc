options:
  parameters:
    comment: Minimal SS-RTT initiator topology. Add/configure UHD Sink and UHD Source for hardware.
    description: 'OFDM PRS SS-RTT initiator '
    generate_options: no_gui
    id: prs_ssrtt_initiator
    output_language: python
    title: PRS SS-RTT Initiator
  states: {}

blocks:
- name: Reply_Delay
  id: variable
  parameters:
    value: int(0.031*samp_rate)/samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1060e6
  states: {}
- name: premble_length
  id: variable
  parameters:
    value: '128'
  states: {}
- name: premble_rep
  id: variable
  parameters:
    value: '17'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '59'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '40'
    step: '1'
    stop: '80'
    value: '45'
  states: {state: disabled}
- name: zc_length
  id: variable
  parameters:
    value: '819'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/cnsl/Desktop/gr-ofdm_prs_ranging/examples/CSV/I_TX.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/cnsl/Desktop/gr-ofdm_prs_ranging/examples/CSV/I_RX.dat
    type: complex
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: POLL trigger
    msg: pmt.PMT_T
    period: '200'
  states: {}
- name: prs_acquisition_logger_0
  id: ofdm_prs_ranging_prs_acquisition_logger
  parameters:
    append: '1'
    comment: Logs every detector output before SS-RTT filtering
    node: '"initiator"'
    path: '"CSV/initiator_acquisition.csv"'
  states: {}
- name: prs_channel_estimator_0
  id: ofdm_prs_ranging_prs_channel_estimator
  parameters:
    active_bins: '512'
    enable_profiling: 'False'
    fft_len: '512'
    mc_ds_gold_code_id: '2'
    prs_symbols: '127'
    samp_rate: samp_rate
    seed: '13990001'
  states: {}
- name: prs_csv_logger_0
  id: ofdm_prs_ranging_prs_csv_logger
  parameters:
    append: '1'
    enable_profiling: 'False'
    path: '"CSV/obs.csv"'
  states: {}
- name: prs_fft_receiver_0
  id: ofdm_prs_ranging_prs_fft_receiver
  parameters:
    active_bins: '512'
    cp_len: '64'
    enable_profiling: 'False'
    fft_len: '512'
    prs_symbols: '127'
    samp_rate: samp_rate
  states: {}
- name: prs_frame_detector_0_0
  id: ofdm_prs_ranging_prs_fft_zc_frame_detector
  parameters:
    active_bins: '512'
    cfo_compensation: 'True'
    channel_id: '1'
    coarse_sync_len: zc_length
    coarse_zc_root: '29'
    comment: Connect UHD Source here
    correlation_fft_len: '4096'
    cp_len: '64'
    enable_profiling: 'False'
    fft_len: '512'
    min_frame_gap: '10000'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '127'
    reply_delay_s: Reply_Delay
    samp_rate: samp_rate
    tail_guard_len: '1000'
    threshold: '0.15'
    time_gating: '1'
    window_after_s: '0.0077'
    window_before_s: '0.00166'
    zc_search_after: 4096-512
    zc_search_before: '512'
    zc_threshold: '0.3'
    zero_guard_len: '1000'
  states: {}
- name: prs_phase_slope_estimator_0
  id: ofdm_prs_ranging_prs_phase_slope_estimator
  parameters:
    active_bins: '512'
    enable_profiling: 'False'
    fft_len: '512'
    max_residual_rms: '1.0'
    samp_rate: samp_rate
  states: {}
- name: prs_rx_timekeeper_0
  id: ofdm_prs_ranging_prs_rx_timekeeper
  parameters:
    comment: Stamp POLL triggers from the UHD RX hardware clock
    samp_rate: samp_rate
    tx_lead_time: '0.1'
  states: {}
- name: prs_source
  id: ofdm_prs_ranging_prs_timed_burst_source
  parameters:
    active_bins: '512'
    attach_tx_time: 'True'
    burst_period: '0.1'
    coarse_sync_len: zc_length
    coarse_zc_root: '25'
    cp_len: '64'
    fft_len: '512'
    mc_ds_gold_code_id: '2'
    pings_per_trigger: '1'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '127'
    samp_rate: samp_rate
    seed: '13990001'
    tail_guard_len: '100'
    tx_amp: '0.7'
    tx_lead_time: '0.1'
    zero_guard_len: '100'
  states: {}
- name: prs_ssrtt_solver_0
  id: ofdm_prs_ranging_prs_ssrtt_solver
  parameters:
    enable_profiling: 'False'
    samp_rate: samp_rate
  states: {}
- name: prs_text_ui_0
  id: ofdm_prs_ranging_prs_text_ui
  parameters:
    refresh_period_s: '3.0'
    response_timeout_s: '1.0'
    role: '"initiator"'
    stale_timeout_s: '1.5'
    use_ansi: 'True'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0563"'
    gain0: tx_gain
    minoutbuf: '1048576'
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0563"'
    dev_args: '"recv_buff_size=25000000,num_recv_frames=1024"'
    gain0: rx_gain
    minoutbuf: '1048576'
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: USRP_SOURCE
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tx_time_out
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: frame_out
  states: {}
- name: virtual_sink_1_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Channel_est
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: USRP_SOURCE
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: USRP_SOURCE
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx_time_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: tx_time_out
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: tx_time_out
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: frame_out
  states: {}
- name: virtual_source_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: frame_out
  states: {}
- name: virtual_source_1_0_0_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Channel_est
  states: {}

connections:
- [blocks_message_strobe_0, strobe, prs_rx_timekeeper_0, trigger_in]
- [prs_channel_estimator_0, channel_out, virtual_sink_1_0_0_0_0_1, '0']
- [prs_channel_estimator_0, event_out, prs_acquisition_logger_0, frame_in]
- [prs_fft_receiver_0, symbols_out, prs_channel_estimator_0, symbols_in]
- [prs_frame_detector_0_0, event_out, prs_acquisition_logger_0, frame_in]
- [prs_frame_detector_0_0, frame_out, virtual_sink_1_0, '0']
- [prs_phase_slope_estimator_0, measurement_out, prs_ssrtt_solver_0, measurement_in]
- [prs_rx_timekeeper_0, timed_trigger_out, prs_source, trigger]
- [prs_source, '0', blocks_file_sink_0, '0']
- [prs_source, '0', uhd_usrp_sink_0, '0']
- [prs_source, tx_time_out, virtual_sink_1, '0']
- [prs_ssrtt_solver_0, ssrtt_out, prs_csv_logger_0, measurement_in]
- [prs_ssrtt_solver_0, ssrtt_out, prs_text_ui_0, measurement_in]
- [uhd_usrp_source_0_0, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', prs_frame_detector_0_0, '0']
- [virtual_source_0_0, '0', prs_rx_timekeeper_0, '0']
- [virtual_source_1, '0', prs_frame_detector_0_0, tx_time_in]
- [virtual_source_1_0, '0', prs_ssrtt_solver_0, tx_time_in]
- [virtual_source_1_0_0, '0', prs_text_ui_0, tx_in]
- [virtual_source_1_0_0_0_0, '0', prs_fft_receiver_0, frame_in]
- [virtual_source_1_0_0_0_0_0, '0', prs_text_ui_0, frame_in]
- [virtual_source_1_0_0_0_1_0_0_0_0, '0', prs_frame_detector_0_0, prs_cfo_in]
- [virtual_source_1_0_0_0_1_0_0_0_0, '0', prs_phase_slope_estimator_0, channel_in]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
