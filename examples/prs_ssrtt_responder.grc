options:
  parameters:
    comment: Minimal SS-RTT responder topology. Add/configure UHD Source and Sink for hardware.
    description: OFDM PRS SS-RTT responder
    generate_options: no_gui
    id: prs_ssrtt_responder
    output_language: python
    title: PRS SS-RTT Responder
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1060e6
  states: {}
- name: premble_length
  id: variable
  parameters:
    value: '256'
  states: {}
- name: premble_rep
  id: variable
  parameters:
    value: '4'
  states: {}
- name: reply_delay_samples
  id: variable
  parameters:
    value: int(0.05*samp_rate)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(30e6)
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '75'
  states: {}
- name: zc_length
  id: variable
  parameters:
    value: '419'
  states: {}
- name: prs_acquisition_logger_0
  id: ofdm_prs_ranging_prs_acquisition_logger
  parameters:
    append: '1'
    comment: Logs every detected POLL before responder filtering
    node: '"responder"'
    path: '"CSV/responder_acquisition_v2.csv"'
  states: {}
- name: prs_channel_estimator_0
  id: ofdm_prs_ranging_prs_channel_estimator
  parameters:
    active_bins: '1024'
    enable_profiling: 'False'
    fft_len: '1024'
    prs_symbols: '16'
    samp_rate: samp_rate
    seed: '13990001'
  states: {}
- name: prs_csv_logger_0
  id: ofdm_prs_ranging_prs_csv_logger
  parameters:
    append: '1'
    comment: Records POLL PRS CFO and phase-slope measurements
    enable_profiling: 'False'
    path: '"CSV/responder_measurements.csv"'
  states: {}
- name: prs_fft_receiver_0
  id: ofdm_prs_ranging_prs_fft_receiver
  parameters:
    active_bins: '1024'
    cp_len: '128'
    enable_profiling: 'False'
    fft_len: '1024'
    prs_symbols: '16'
    samp_rate: samp_rate
  states: {}
- name: prs_frame_detector_0
  id: ofdm_prs_ranging_prs_frame_detector
  parameters:
    active_bins: '1024'
    channel_id: '0'
    coarse_sync_len: zc_length
    coarse_zc_root: '25'
    comment: Connect UHD Source here
    cp_len: '128'
    enable_profiling: 'False'
    fft_len: '1024'
    min_frame_gap: '10000'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '16'
    reply_delay_s: '0.05'
    samp_rate: samp_rate
    tail_guard_len: '1000'
    threshold: '0.35'
    time_gating: 'False'
    window_after_s: '0.004'
    window_before_s: '0.0002'
    zc_threshold: '0.5'
    zero_guard_len: '1000'
  states: {state: disabled}
- name: prs_frame_detector_0_0
  id: ofdm_prs_ranging_prs_fft_zc_frame_detector
  parameters:
    active_bins: '1024'
    cfo_compensation: 'True'
    channel_id: '0'
    coarse_sync_len: zc_length
    coarse_zc_root: '25'
    comment: Connect UHD Source here
    correlation_fft_len: '4096'
    cp_len: '128'
    enable_profiling: 'True'
    fft_len: '1024'
    min_frame_gap: '10000'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '16'
    reply_delay_s: '0.05'
    samp_rate: samp_rate
    tail_guard_len: '1000'
    threshold: '0.35'
    time_gating: 'False'
    window_after_s: '0.004'
    window_before_s: '0.0002'
    zc_search_after: 4096-512
    zc_search_before: '512'
    zc_threshold: '0.5'
    zero_guard_len: '1000'
  states: {}
- name: prs_phase_slope_estimator_0
  id: ofdm_prs_ranging_prs_phase_slope_estimator
  parameters:
    active_bins: '1024'
    enable_profiling: 'False'
    fft_len: '1024'
    max_residual_rms: '1.0'
    samp_rate: samp_rate
  states: {}
- name: prs_source
  id: ofdm_prs_ranging_prs_timed_burst_source
  parameters:
    active_bins: '1024'
    attach_tx_time: 'True'
    burst_period: '0.1'
    coarse_sync_len: zc_length
    coarse_zc_root: '29'
    cp_len: '128'
    fft_len: '1024'
    pings_per_trigger: '1'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '16'
    samp_rate: samp_rate
    seed: '13990001'
    tail_guard_len: '1000'
    tx_amp: '0.7'
    tx_lead_time: '0.5'
    zero_guard_len: '1000'
  states: {}
- name: prs_ssrtt_responder_0
  id: ofdm_prs_ranging_prs_ssrtt_responder
  parameters:
    enable_profiling: 'False'
    reply_delay_samples: reply_delay_samples
    samp_rate: samp_rate
  states: {}
- name: prs_text_ui_0
  id: ofdm_prs_ranging_prs_text_ui
  parameters:
    refresh_period_s: '2.0'
    response_timeout_s: '1.0'
    role: '"responder"'
    stale_timeout_s: '1.5'
    use_ansi: 'True'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0563"'
    gain0: tx_gain
    minoutbuf: |
      1048576
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0563"'
    dev_args: '"recv_buff_size=20000000,num_recv_frames=700"'
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: trigger_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tx_time_out
  states: {}
- name: virtual_sink_1_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Channel_est
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: trigger_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx_time_out
  states: {}
- name: virtual_source_1_0_0_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Channel_est
  states: {}

connections:
- [prs_channel_estimator_0, channel_out, virtual_sink_1_0_0_0_0_1, '0']
- [prs_fft_receiver_0, symbols_out, prs_channel_estimator_0, symbols_in]
- [prs_frame_detector_0, event_out, prs_acquisition_logger_0, frame_in]
- [prs_frame_detector_0, frame_out, prs_fft_receiver_0, frame_in]
- [prs_frame_detector_0, frame_out, prs_text_ui_0, frame_in]
- [prs_frame_detector_0_0, event_out, prs_acquisition_logger_0, frame_in]
- [prs_frame_detector_0_0, frame_out, prs_fft_receiver_0, frame_in]
- [prs_frame_detector_0_0, frame_out, prs_text_ui_0, frame_in]
- [prs_phase_slope_estimator_0, measurement_out, prs_csv_logger_0, measurement_in]
- [prs_phase_slope_estimator_0, measurement_out, prs_ssrtt_responder_0, measurement_in]
- [prs_phase_slope_estimator_0, measurement_out, prs_text_ui_0, measurement_in]
- [prs_source, '0', uhd_usrp_sink_0, '0']
- [prs_source, tx_time_out, virtual_sink_0_0, '0']
- [prs_ssrtt_responder_0, trigger_out, virtual_sink_0, '0']
- [uhd_usrp_source_0_0, '0', prs_frame_detector_0, '0']
- [uhd_usrp_source_0_0, '0', prs_frame_detector_0_0, '0']
- [virtual_source_0, '0', prs_source, trigger]
- [virtual_source_1, '0', prs_text_ui_0, tx_in]
- [virtual_source_1_0_0_0_1_0_0_0_0, '0', prs_frame_detector_0_0, prs_cfo_in]
- [virtual_source_1_0_0_0_1_0_0_0_0, '0', prs_phase_slope_estimator_0, channel_in]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
