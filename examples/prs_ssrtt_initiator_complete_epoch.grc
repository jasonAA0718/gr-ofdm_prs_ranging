options:
  parameters:
    comment: |-
      Static configurable 1..8-anchor schedule.
      Complete epochs only after finalization;
    description: 'OFDM PRS SS-RTT initiator '
    generate_options: no_gui
    id: prs_ssrtt_initiator_complete_epoch
    output_language: python
    title: PRS Four-Anchor Initiator
  states: {}

blocks:
- name: anchor_config
  id: variable
  parameters:
    comment: ranging_cycle_time
    value: load_anchor_config("/home/cnsl/Desktop/gr-ofdm_prs_ranging/tools/anchors_enu.csv")
  states: {}
- name: anchor_ids
  id: variable
  parameters:
    comment: Delay corresponding anchor ID
    value: anchor_config[0]
  states: {}
- name: anchor_ids
  id: variable
  parameters:
    comment: Delay corresponding anchor ID
    value: '[0]'
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: 1330e6
  states: {}
- name: obs_log
  id: variable
  parameters:
    value: '"/home/cnsl/Desktop/gr-ofdm_prs_ranging/examples/CSV/complete_epoch_measurements.csv"'
  states: {}
- name: premble_length
  id: variable
  parameters:
    value: '128'
  states: {}
- name: premble_rep
  id: variable
  parameters:
    value: '17'
  states: {}
- name: processing_grace_s
  id: variable
  parameters:
    comment: ranging_cycle_time
    value: '0.1'
  states: {}
- name: receive_early_s
  id: variable
  parameters:
    comment: |-
      Anchor received window 
      before time
    value: '0.002'
  states: {}
- name: receive_late_s
  id: variable
  parameters:
    comment: |-
      Anchor received window 
      before time
    value: '0.002'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '56'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30000000'
  states: {}
- name: time_delays
  id: variable
  parameters:
    comment: |-
      Static schedule in seconds; delays correspond to anchor_ids by index.
      The minimal slot space:
      delay_1 - delay_0 = before + after + frame_length
    value: '[0.041, 0.051, 0.067]'
  states: {}
- name: time_delays
  id: variable
  parameters:
    comment: |-
      Static schedule in seconds; delays correspond to anchor_ids by index.
      The minimal slot space:
      delay_1 - delay_0 = before + after + frame_length
    value: '[0.041]'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '45'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '40'
    step: '1'
    stop: '80'
    value: '45'
  states: {state: disabled}
- name: zc_length
  id: variable
  parameters:
    value: '819'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: POLL trigger
    msg: pmt.PMT_T
    period: '500'
  states: {}
- name: cycle_diagnostic_debug
  id: blocks_message_debug
  parameters:
    comment: Ranging cycle summary/diagnostics; epoch_out is separate.
    en_uvec: 'False'
    log_level: err
  states: {state: disabled}
- name: cycle_summary_debug
  id: blocks_message_debug
  parameters:
    comment: Ranging cycle summary/diagnostics; epoch_out is separate.
    en_uvec: 'False'
  states: {state: disabled}
- name: cycle_summary_debug_0
  id: blocks_message_debug
  parameters:
    comment: Ranging cycle summary/diagnostics; epoch_out is separate.
    en_uvec: 'False'
  states: {}
- name: cycle_summary_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Ranging cycle summary/diagnostics; epoch_out is separate.
    en_uvec: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import sys; sys.path.insert(0, "/home/cnsl/Desktop/gr-ofdm_prs_ranging/tools"); from anchor_csv_loader import load_anchor_config
  states: {}
- name: ofdm_prs_ranging_prs_position_solver_0
  id: ofdm_prs_ranging_prs_position_solver
  parameters:
    anchor_ids: anchor_config[0]
    anchor_positions_m: anchor_config[1]
    vehicle_height_m: '0.0'
  states: {}
- name: prs_acquisition_logger_0
  id: ofdm_prs_ranging_prs_acquisition_logger
  parameters:
    append: '1'
    comment: Logs every detector output before SS-RTT filtering
    node: '"initiator"'
    path: '"/home/cnsl/Desktop/gr-ofdm_prs_ranging/examples/CSV/complete_epoch_acquisition.csv"'
  states: {}
- name: prs_channel_estimator_0
  id: ofdm_prs_ranging_prs_channel_estimator
  parameters:
    active_bins: '512'
    fft_len: '512'
    mc_ds_gold_code_id: '2'
    prs_symbols: '127'
    samp_rate: samp_rate
    seed: '13990001'
  states: {}
- name: prs_csv_logger_0
  id: ofdm_prs_ranging_prs_csv_logger
  parameters:
    append: '1'
    path: obs_log
  states: {}
- name: prs_fft_receiver_0
  id: ofdm_prs_ranging_prs_fft_receiver
  parameters:
    active_bins: '512'
    cp_len: '64'
    fft_len: '512'
    prs_symbols: '127'
    samp_rate: samp_rate
  states: {}
- name: prs_frame_detector_0_0
  id: ofdm_prs_ranging_prs_fft_zc_frame_detector
  parameters:
    active_bins: '512'
    cfo_compensation: 'True'
    channel_id: '1'
    coarse_sync_len: zc_length
    coarse_zc_root: '29'
    comment: Connect UHD Source here
    correlation_fft_len: '4096'
    cp_len: '64'
    fft_len: '512'
    min_frame_gap: '10000'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '127'
    reply_delay_s: '0.0'
    samp_rate: samp_rate
    threshold: '0.6'
    time_gating: '1'
    window_after_s: '0.0077'
    window_before_s: '0.00166'
    zc_search_after: 4096-512
    zc_search_before: '512'
    zc_threshold: '0.5'
  states: {}
- name: prs_multi_anchor_cycle_0
  id: ofdm_prs_ranging_prs_multi_anchor_cycle
  parameters:
    anchor_ids: anchor_ids
    coarse_sync_len: zc_length
    cfo_max_age_s: '5.0'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    processing_grace_s: processing_grace_s
    samp_rate: samp_rate
    time_delays: time_delays
    window_after_s: receive_late_s
    window_before_s: receive_early_s
  states: {}
- name: prs_phase_slope_estimator_0
  id: ofdm_prs_ranging_prs_phase_slope_estimator
  parameters:
    active_bins: '512'
    fft_len: '512'
    max_residual_rms: '1.0'
    samp_rate: samp_rate
  states: {}
- name: prs_position_csv_logger_0
  id: ofdm_prs_ranging_prs_position_csv_logger
  parameters:
    append: 'True'
    comment: Successful fixes and solver failures from finalized observations
    path: '"/home/cnsl/Desktop/gr-ofdm_prs_ranging/examples/CSV/complete_epoch_positions.csv"'
  states: {}
- name: prs_rx_timekeeper_0
  id: ofdm_prs_ranging_prs_rx_timekeeper
  parameters:
    comment: Stamp POLL triggers from the UHD RX hardware clock
    samp_rate: samp_rate
    tx_lead_time: '0.1'
  states: {}
- name: prs_source
  id: ofdm_prs_ranging_prs_timed_burst_source
  parameters:
    active_bins: '512'
    attach_tx_time: 'True'
    burst_period: '0.1'
    coarse_sync_len: zc_length
    coarse_zc_root: '25'
    cp_len: '64'
    fft_len: '512'
    mc_ds_gold_code_id: '2'
    pings_per_trigger: '1'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '127'
    samp_rate: samp_rate
    seed: '13990001'
    tx_amp: '0.7'
    tx_lead_time: '0.1'
  states: {}
- name: prs_ssrtt_solver_0
  id: ofdm_prs_ranging_prs_ssrtt_solver
  parameters:
    samp_rate: samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=32712EF"'
    gain0: tx_gain
    minoutbuf: '1048576'
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=32712EF"'
    dev_args: '"recv_buff_size=25000000,num_recv_frames=1024"'
    gain0: rx_gain
    minoutbuf: '1048576'
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: USRP_SOURCE
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: slope_meas
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: range
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: tx_time
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: clock
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: USRP_SOURCE
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: slope_meas
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: range
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: tx_time
  states: {}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: clock
  states: {}

connections:
- [blocks_message_strobe_0, strobe, prs_rx_timekeeper_0, trigger_in]
- [ofdm_prs_ranging_prs_position_solver_0, diagnostic_out, cycle_summary_debug_0_0, print]
- [ofdm_prs_ranging_prs_position_solver_0, diagnostic_out, prs_position_csv_logger_0, diagnostic_in]
- [ofdm_prs_ranging_prs_position_solver_0, position_out, cycle_summary_debug_0, print]
- [ofdm_prs_ranging_prs_position_solver_0, position_out, prs_position_csv_logger_0, position_in]
- [prs_channel_estimator_0, channel_out, prs_phase_slope_estimator_0, channel_in]
- [prs_channel_estimator_0, event_out, prs_acquisition_logger_0, frame_in]
- [prs_fft_receiver_0, symbols_out, prs_channel_estimator_0, symbols_in]
- [prs_frame_detector_0_0, event_out, prs_acquisition_logger_0, frame_in]
- [prs_frame_detector_0_0, frame_out, prs_fft_receiver_0, frame_in]
- [prs_multi_anchor_cycle_0, cycle_out, cycle_summary_debug, print]
- [prs_multi_anchor_cycle_0, diagnostic_out, cycle_diagnostic_debug, print]
- [prs_multi_anchor_cycle_0, measurement_out, prs_csv_logger_0, measurement_in]
- [prs_multi_anchor_cycle_0, observation_out, ofdm_prs_ranging_prs_position_solver_0, epoch_in]
- [prs_multi_anchor_cycle_0, solver_measurement_out, prs_ssrtt_solver_0, measurement_in]
- [prs_multi_anchor_cycle_0, solver_tx_out, prs_ssrtt_solver_0, tx_time_in]
- [prs_multi_anchor_cycle_0, window_out, prs_frame_detector_0_0, tx_time_in]
- [prs_phase_slope_estimator_0, measurement_out, virtual_sink_0_0, '0']
- [prs_rx_timekeeper_0, clock_out, virtual_sink_0_0_1_0, '0']
- [prs_rx_timekeeper_0, timed_trigger_out, prs_source, trigger]
- [prs_source, '0', uhd_usrp_sink_0, '0']
- [prs_source, tx_time_out, virtual_sink_0_0_1, '0']
- [prs_ssrtt_solver_0, ssrtt_out, virtual_sink_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', prs_rx_timekeeper_0, '0']
- [uhd_usrp_source_0_0, '0', virtual_sink_0, '0']
- [virtual_source_0_0, '0', prs_frame_detector_0_0, '0']
- [virtual_source_0_0_0, '0', prs_multi_anchor_cycle_0, measurement_in]
- [virtual_source_0_0_0_0, '0', prs_multi_anchor_cycle_0, range_in]
- [virtual_source_0_0_0_1, '0', prs_multi_anchor_cycle_0, tx_time_in]
- [virtual_source_0_0_0_1_0, '0', prs_multi_anchor_cycle_0, clock_in]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
