options:
  parameters:
    comment: Minimal SS-RTT responder topology. Add/configure UHD Source and Sink for hardware.
    description: OFDM PRS SS-RTT responder
    generate_options: no_gui
    id: prs_ssrtt_responder_anchor0
    output_language: python
    title: PRS Anchor 0 (Static Two-Anchor Experiment)
  states: {}

blocks:
- name: T_burst
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: anchor_id
  id: variable
  parameters:
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1060e6
  states: {}
- name: premble_length
  id: variable
  parameters:
    value: '128'
  states: {}
- name: premble_rep
  id: variable
  parameters:
    value: '17'
  states: {}
- name: reply_delay_samples
  id: variable
  parameters:
    value: int(response_delay_seconds*samp_rate + 0.5)
  states: {}
- name: response_delay_seconds
  id: variable
  parameters:
    comment: Match initiator time_delays entry; seconds, converted once to integer samples.
    value: '0.041'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '62'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '76'
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '30000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {state: disabled}
- name: zc_length
  id: variable
  parameters:
    value: '819'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/cnsl/Desktop/gr-ofdm_prs_ranging/examples/CSV/RX.dat
    type: complex
  states: {state: disabled}
- name: ofdm_prs_ranging_prs_window_capture_0
  id: ofdm_prs_ranging_prs_window_capture
  parameters:
    acquisition_enabled: 'True'
    active_bins: '512'
    candidate_margin_after: '4096'
    candidate_margin_before: '4096'
    coarse_sync_len: '819'
    cp_len: '64'
    enable_profiling: 'False'
    fft_len: '512'
    min_frame_gap: '10000'
    preamble_len: '128'
    preamble_repeats: '17'
    prs_symbols: '127'
    queue_depth: '2'
    samp_rate: 30e6
    threshold: '0.12'
  states: {}
- name: ofdm_prs_ranging_prs_zc_frame_sync_0
  id: ofdm_prs_ranging_prs_zc_frame_sync
  parameters:
    active_bins: '512'
    affinity: '[2]'
    channel_id: '0'
    coarse_sync_len: '819'
    coarse_zc_root: '25'
    cp_len: '64'
    enable_profiling: '0'
    fft_len: '512'
    preamble_len: '128'
    preamble_repeats: '17'
    preamble_threshold: '0.15'
    prs_symbols: '127'
    samp_rate: 30e6
    zc_threshold: '0.35'
  states: {}
- name: prs_acquisition_logger_0
  id: ofdm_prs_ranging_prs_acquisition_logger
  parameters:
    append: '1'
    comment: Logs every detected POLL before responder filtering
    node: '"responder"'
    path: '"CSV/anchor0_acquisition.csv"'
  states: {}
- name: prs_channel_estimator_0
  id: ofdm_prs_ranging_prs_channel_estimator
  parameters:
    active_bins: '512'
    enable_profiling: '0'
    fft_len: '512'
    mc_ds_gold_code_id: '2'
    prs_symbols: '127'
    samp_rate: samp_rate
    seed: '13990001'
  states: {}
- name: prs_csv_logger_0
  id: ofdm_prs_ranging_prs_csv_logger
  parameters:
    append: '1'
    comment: Records POLL PRS CFO and phase-slope measurements
    enable_profiling: '0'
    path: '"CSV/anchor0_measurements.csv"'
  states: {}
- name: prs_fft_receiver_0
  id: ofdm_prs_ranging_prs_fft_receiver
  parameters:
    active_bins: '512'
    cp_len: '64'
    enable_profiling: '0'
    fft_len: '512'
    prs_symbols: '127'
    samp_rate: samp_rate
  states: {}
- name: prs_phase_slope_estimator_0
  id: ofdm_prs_ranging_prs_phase_slope_estimator
  parameters:
    active_bins: '512'
    enable_profiling: '0'
    fft_len: '512'
    max_residual_rms: '1.0'
    samp_rate: samp_rate
  states: {}
- name: prs_source
  id: ofdm_prs_ranging_prs_timed_burst_source
  parameters:
    active_bins: '512'
    attach_tx_time: 'True'
    burst_period: '0.1'
    coarse_sync_len: zc_length
    coarse_zc_root: '29'
    cp_len: '64'
    fft_len: '512'
    mc_ds_gold_code_id: '2'
    pings_per_trigger: '1'
    preamble_len: premble_length
    preamble_repeats: premble_rep
    prs_symbols: '127'
    samp_rate: samp_rate
    seed: '13990001'
    tx_amp: '0.7'
    tx_lead_time: '0.1'
  states: {}
- name: prs_ssrtt_responder_0
  id: ofdm_prs_ranging_prs_ssrtt_responder
  parameters:
    anchor_id: anchor_id
    enable_profiling: '0'
    reply_delay_samples: reply_delay_samples
    samp_rate: samp_rate
  states: {}
- name: prs_text_ui_0
  id: ofdm_prs_ranging_prs_text_ui
  parameters:
    refresh_period_s: '2.0'
    response_timeout_s: '1.0'
    role: '"responder"'
    stale_timeout_s: '1.5'
    use_ansi: 'True'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0564"'
    gain0: tx_gain
    minoutbuf: '1048576'
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0564"'
    dev_args: '"recv_buff_size=20000000,num_recv_frames=700"'
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: trigger_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tx_time_out
  states: {}
- name: virtual_sink_1_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Channel_est
  states: {}
- name: virtual_sink_1_0_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: Frame_Detect_out
  states: {}
- name: virtual_sink_1_0_0_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: slot
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: trigger_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx_time_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Frame_Detect_out
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: Frame_Detect_out
  states: {}
- name: virtual_source_1_0_0_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Channel_est
  states: {}
- name: virtual_source_1_0_0_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: slot
  states: {}

connections:
- [ofdm_prs_ranging_prs_window_capture_0, candidate_out, ofdm_prs_ranging_prs_zc_frame_sync_0, candidate_in]
- [ofdm_prs_ranging_prs_window_capture_0, event_out, prs_acquisition_logger_0, frame_in]
- [ofdm_prs_ranging_prs_zc_frame_sync_0, slot_release, virtual_sink_1_0_0_0_0_1_0_0, '0']
- [ofdm_prs_ranging_prs_zc_frame_sync_0, synchronized_frame_out, virtual_sink_1_0_0_0_0_1_0, '0']
- [prs_channel_estimator_0, channel_out, virtual_sink_1_0_0_0_0_1, '0']
- [prs_channel_estimator_0, event_out, prs_acquisition_logger_0, frame_in]
- [prs_fft_receiver_0, symbols_out, prs_channel_estimator_0, symbols_in]
- [prs_phase_slope_estimator_0, measurement_out, prs_csv_logger_0, measurement_in]
- [prs_phase_slope_estimator_0, measurement_out, prs_ssrtt_responder_0, measurement_in]
- [prs_phase_slope_estimator_0, measurement_out, prs_text_ui_0, measurement_in]
- [prs_source, '0', uhd_usrp_sink_0_0, '0']
- [prs_source, tx_time_out, virtual_sink_0_0, '0']
- [prs_ssrtt_responder_0, trigger_out, virtual_sink_0, '0']
- [uhd_usrp_source_0_0_0, '0', ofdm_prs_ranging_prs_window_capture_0, '0']
- [virtual_source_0, '0', prs_source, trigger]
- [virtual_source_1, '0', prs_text_ui_0, tx_in]
- [virtual_source_1_0, '0', prs_text_ui_0, frame_in]
- [virtual_source_1_0_0, '0', prs_fft_receiver_0, frame_in]
- [virtual_source_1_0_0_0_1_0_0_0_0, '0', prs_phase_slope_estimator_0, channel_in]
- [virtual_source_1_0_0_0_1_0_0_0_0_0, '0', ofdm_prs_ranging_prs_window_capture_0, slot_release]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
